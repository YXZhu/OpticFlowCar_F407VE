# Keil uVision project OpticFlowCar_F407VE.uvprojx, settings and files
target OpticFlowCar_F407VE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: OpticFlowCar_F407VE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,OS_SUPPORT
  c include: ../Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Drivers/CMSIS/Include;        ..\Drivers\BSP\mpu9250;        ..\Drivers\BSP;        ..\Drivers\BSP\mpu9250\eMPL;        ..\Drivers\BSP\mpu9250\eMPL-hal;        ..\Drivers\BSP\mpu9250\include;        ..\Drivers\BSP\mpu9250\mllite;        ..\Drivers\BSP\mpu9250\mpl;        ..\Drivers\BSP\mpu9250\stm32L;        ..\Middlewares\Third_Party\SEGGER\RTT;        ..\Drivers\BSP\VL53L0X_Api\core\inc;        ..\Drivers\BSP\VL53L0X_Api\platform\inc;        ..\Drivers\BSP\VL53L0X_Api;        ..\Middlewares\Third_Party\STemWinLibrary532\Config;        ..\Middlewares\Third_Party\STemWinLibrary532\inc;        ..\Middlewares\Third_Party\STemWinLibrary532\Software;        ..\MDK-ARM;        ..\Middlewares\Third_Party\Easytracer
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\OpticFlowCar_F407VE\OpticFlowCar_F407VE.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: dwt_stm32_delay.c exflash.c eeprom.c main.c gpio.c crc.c dcmi.c dma.c freertos.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: arm_cortexM4lf_math.lib
    ..//Src/: system_stm32f4xx.c
  group Drivers/BSP
    ../Drivers/BSP/: motoctrl_1.c motoctrl_2.c pmw3901.c lcd.c ov7670.c ov7670.h sccb.c ServoCtrl.c
    ../Drivers/BSP/mpu9250/: mpu9250.c mpu9250_test.c
    ../Drivers/BSP/VL53L0X_Api/: vl53l0x.c vl53l0x.h vl53l0x_cali.c vl53l0x_cali.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/RTT
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
  group Middlewares/Easytracer
    ../Middlewares/Third_Party/Easytracer/: EasyTracer.c
  group MPU9250/eMPL
    ../Drivers/BSP/mpu9250/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group MPU9250/eMPL-hal
    ../Drivers/BSP/mpu9250/eMPL-hal/: eMPL_outputs.c
  group MPU9250/mpl
    ../Drivers/BSP/mpu9250/mpl/: libmpllib.lib
    ../Drivers/BSP/mpu9250/stm32L/: log_stm32.c
  group MPU9250/mllite
    ../Drivers/BSP/mpu9250/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group VL53L0X_API
    ../Drivers/BSP/VL53L0X_Api/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../Drivers/BSP/VL53L0X_Api/platform/src/: vl53l0x_platform.c vl53l0x_platform_log.c
  group GUI
    ../Middlewares/Third_Party/STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c TOUCH_GUI.c GUIDRV_Template.c DataDisplayDLG.c WindowDLG.c picture.c DataDisplayDLG.h
    ../Middlewares/Third_Party/STemWinLibrary532/Lib/: STemWin532_CM4_OS_Keil.lib
    ../Middlewares/Third_Party/STemWinLibrary532/OS/: GUI_X_OS.c
    ../Middlewares/Third_Party/STemWinLibrary532/Software/: CameraViewDLG.c
target OpticFlowCar_F407VE_SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: OpticFlowCar_F407VE_RAM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,VECT_TAB_SRAM
  c include: ../Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                      ../Middlewares/Third_Party/FreeRTOS/Source/include;                      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                      ../Drivers/CMSIS/Include;                      ..\Drivers\BSP\mpu9250;                      ..\Drivers\BSP;                      ..\Drivers\BSP\mpu9250\eMPL;                      ..\Drivers\BSP\mpu9250\eMPL-hal;                      ..\Drivers\BSP\mpu9250\include;                      ..\Drivers\BSP\mpu9250\mllite;                      ..\Drivers\BSP\mpu9250\mpl;                      ..\Drivers\BSP\mpu9250\stm32L;                      ..\Middlewares\Third_Party\SEGGER\RTT;                      ..\Drivers\BSP\VL53L0X_Api\core\inc;                      ..\Drivers\BSP\VL53L0X_Api\platform\inc;                      ..\Drivers\BSP\VL53L0X_Api
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x19000
  memory RVCT9: RAM 0x20019000 size 0x7000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\OpticFlowCar_F407VE_RAM\OpticFlowCar_F407VE_SRAM.sct
software components: CMSIS:CORE 5.1.2
